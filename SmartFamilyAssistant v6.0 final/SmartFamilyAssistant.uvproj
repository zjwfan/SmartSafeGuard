# Keil uVision project SmartFamilyAssistant.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SmartFamilyAssistant +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Common.c GSM.c KeyScan.c main.c LCD12864.c environment.c Timer0.c Serial 2.c STARTUP.A51
  group Hearder
    ./: Option.h STC15F2K.h
  group my_driver
    ./my driver/: DHT11.c Mq2.c Temp.c
